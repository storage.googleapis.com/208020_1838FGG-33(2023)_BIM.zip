Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-26T19:02:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 26 19:02:23 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8a4ff089-cb36-42f2-8fd8-901cdd0d1ac6\be2c2bca-79aa-4cc8-989e-64712514f0ce\ifc * Database version: 5507 * Database creation date: Fri Apr 26 19:02:22 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 26 19:02:23 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 26 19:02:23 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 1838FGG-33 Kitchen faucet, 1838FGG-33(2023):1838FGG-33 Kitchen faucet:69653
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass - Matt black
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 261 mm; NominalHeight: 338 mm; NominalWidth: 54 mm
Type - General - Author: BIMStone; BIMObjectName: 1838FGG-33(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 20/04/2024
Type - Green Building Properties - Approval KIWA SE Energy Mark: 1605; Approval KIWA SE Type Approval: 1588; EAN Number: 6414150103223; EN Standard: EN 817; ETIM Class Number: EC011431 Kitchen mixing tap; Noise Class: I (ISO 3822); RSK Number: 8312020; Sales Package dimensions (LxWxH): 754 x 334 x 63; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/1838FGG-33; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL KIWA SE Energy Mark: http://static.oras.com/KIWASEEnergyMark/1838FGG-33; URL KIWA SE Type Approval: http://static.oras.com/KIWASETypeApproval/1838FGG-33; URL Materials Declaration: http://www.oras.com/fileadmin/resources/185191_1838FGG-33_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/1838FGG-33; VVS Number: 705924311
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/1838FGG-33; 3D View: https://static.oras.com/AR/1838FGG-33; Catalog Drawing URL: http://static.oras.com/catdrw/1838FGG-33; Dimension Drawing URL: http://static.oras.com/dimdrw/1838FGG-33; FDV Document URL: http://www.oras.com/datasheet/1838FGG-33/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1838FGG-33; Group: Kitchen faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/1838FGG-33; Interactive AR View URL: https://static.oras.com/AR/1838FGG-33; Long Marketing: Kitchen faucet with high spout. Swivel spout and aerator. Spout’s swing angle is factory preset at 120° (can be limited to 0° or 60°). Lever is equipped with an eco-button for limiting water temperature and flowrate, which can be bypassed by pressing the button. With flexible pipes.; Manufacturer: Oras; Market: International;Sweden;Denmark; Mobile Product Information URL: http://mpi.oras.com/1838FGG-33; Model: 1838FGG-33 Kitchen faucet; Name_en: 1838FGG-33 Kitchen faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1838FGG-33; Product Family: Oras Vega Eco; Product Image URL: http://static.oras.com/image/1838FGG-33; Product URL: http://static.oras.com/1838FGG-33; Spare-Part Information URL: http://static.oras.com/sp/1838FGG-33; Technical DataSheet URL: http://www.oras.com/datasheet/1838FGG-33/en; Type Name: 1838FGG-33 Kitchen faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass - Matt black
Type - Mechanical - Advanced Features: 3S-installation system for safe and simple mounting; Aerator: Standard aerator; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Eco Flow At 300kPa: 0.00388461 m3/s; Flow Rate At 300kPa: 0.00494405 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols;Eco feature for water flow; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Pressure Loss With Flow 01ls: 145000 Pa; Spout Projection: 178 mm; Spout Swivel Range: 120° (60° / 0°); Spout Type: Swivel spout; Surface treatment: Matt black; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Matt black; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1838FGG-33(2023); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1838FGG-33; Name: 1838FGG-33 Kitchen faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 55 x 260 x 340 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.121663 m2; Volume: 0.00475205 m3
Identity Data - Mark: 30
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1838FGG-33(2023): 1838FGG-33 Kitchen faucet; Family and Type: 1838FGG-33(2023): 1838FGG-33 Kitchen faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1838FGG-33(2023): 1838FGG-33 Kitchen faucet; Type Id: 1838FGG-33(2023): 1838FGG-33 Kitchen faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
